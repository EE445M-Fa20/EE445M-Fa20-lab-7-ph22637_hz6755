# Keil uVision project Lab1.uvprojx, settings and files
target Lab1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab1.c
    ../RTOS_Labs_common/: OS.c Interpreter.c ST7735.c UART0int.c eDisk.c efile.c ADC.c osasm.s
    ../inc/: LaunchPad.c PLL.c ADCSWTrigger.c LPF.c IRDistance.c Timer4A.c WTimer0A.c Timer5A.c
software components: CMSIS:CORE 5.0.2
